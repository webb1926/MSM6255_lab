# Keil uVision project msm6255_lab.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: msm6255 +hex
  c flags: Optimize=8 SizeSpeed=1
  group msm6255_lab
    ./src/: font.c layout.c lcd_func.c lcd_init.c main.c lcd_asm.a
  group library
    C:/Keil/C51/LIB/: C51S.LIB
